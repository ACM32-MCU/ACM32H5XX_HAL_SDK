# Keil uVision project Project.uvprojx, settings and files
target Project (6150000::V6.15::ARMCLANG)
  device: ACM32H528IIT7-G Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.2
  cpu: IRAM(0x20008000,0x00058000) IRAM2(0x20000000,0x00008000) IROM(0x08002000,0x001FE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __DSP_PRESENT,ACM32H5XX_176_EVB,NDEBUG
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\..\..\..\BSP\LTDC;..\User;..\MDK-ARM;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\portable\ARMv8M\non_secure;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\portable\ARMv8M\non_secure\portable;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\portable\ARMv8M\non_secure\portable\GCC\ARM_CM33_NTZ;..\..\..\..\..\..\Middlewares\Third_Party\libmodbus\src;..\..\..\..\..\..\Middlewares\Third_Party\libmodbus\inc
  asm include: C:\Keil\ARM\INC\ARM;..\..\..\..\..\..\Middlewares\Third_Party\RTOS2\RTX\Include;..\..\..\..\..\..\Middlewares\Third_Party\RTOS2\RTX\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1fe000
  memory RVCT9: RAM 0x20008000 size 0x58000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Example/MDK-ARM
    ../../../../../../Drivers/Device/ARM/: startup_acm32h5xx.s
  group Drivers/CMSIS
    ../../../../../../Drivers/Device/: system_acm32h5xx.c system_accelerate.c
  group Example/User
    ../User/: main.c acm32h5xx_it.c acm32h5xx_hal_msp.c
  group BSP
    ../../../../BSP/: acm32h5xx_coreboard.c
  group Drivers/HAL_Driver
    ../../../../../../Drivers/HAL_Driver/Src/: hal.c hal_rcc.c hal_cortex.c hal_exti.c hal_gpio.c hal_dma.c hal_uart.c hal_efuse.c hal_ltdc.c hal_dma2d.c hal_ospi.c hal_spi.c
  group Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/portable/ARMv8M/non_secure/portable/GCC/ARM_CM33_NTZ/: mpu_wrappers_v2_asm.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/portable/MemMang/: heap_4.c
  group Third_Party/FreeRTOS/Porting
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/portable/ARMv8M/non_secure/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/portable/ARMv8M/non_secure/portable/GCC/ARM_CM33_NTZ/: portasm.c
  group Third_Party/Modbus
    ../User/: bsp_485.c
    ../../../../../../Middlewares/Third_Party/libmodbus/src/: modbus.c modbus-data.c modbus-rtu.c uart_device.c errno.c
