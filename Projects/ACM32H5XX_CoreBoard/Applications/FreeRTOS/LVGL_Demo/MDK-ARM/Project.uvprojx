# Keil uVision project Project.uvprojx, settings and files
target Project (6150000::V6.15::ARMCLANG)
  device: ACM32H528IIT7-G Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.2
  cpu: IRAM(0x20008000,0x00058000) IRAM2(0x20000000,0x00008000) IROM(0x08002000,0x001FE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1
  c define: __DSP_PRESENT,ACM32H5XX_176_EVB
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\..\..\..\BSP\LTDC;..\User;..\MDK-ARM;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\portable\ARMv8M\non_secure;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\portable\ARMv8M\non_secure\portable;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\portable\ARMv8M\non_secure\portable\GCC\ARM_CM33_NTZ;..\..\..\..\BSP\ospi;..\User\lvgl;..\..\..\..\..\..\Middlewares\Third_Party\lvgl\lvgl-release-v8.4
  asm include: C:\Keil\ARM\INC\ARM;..\..\..\..\..\..\Middlewares\Third_Party\RTOS2\RTX\Include;..\..\..\..\..\..\Middlewares\Third_Party\RTOS2\RTX\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1fe000
  memory RVCT9: RAM 0x20008000 size 0x58000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Project.sct
  group Example/MDK-ARM
    ../../../../../../Drivers/Device/ARM/: startup_acm32h5xx.s
  group Drivers/CMSIS
    ../../../../../../Drivers/Device/: system_acm32h5xx.c system_accelerate.c
  group Example/User
    ../User/: main.c acm32h5xx_it.c acm32h5xx_hal_msp.c task_disp.c
  group BSP
    ../../../../BSP/: acm32h5xx_coreboard.c
    ../../../../BSP/PSRAM/: xccela_opi.c
    ../../../../BSP/ospi/: drv_ospi.c
    ../../../../BSP/LTDC/: bsp_lcd.c
  group Drivers/HAL_Driver
    ../../../../../../Drivers/HAL_Driver/Src/: hal.c hal_rcc.c hal_cortex.c hal_exti.c hal_gpio.c hal_dma.c hal_uart.c hal_efuse.c hal_ltdc.c hal_dma2d.c hal_ospi.c hal_spi.c
  group Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/portable/ARMv8M/non_secure/portable/GCC/ARM_CM33_NTZ/: mpu_wrappers_v2_asm.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/portable/MemMang/: heap_4.c
  group Third_Party/FreeRTOS/Porting
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/portable/ARMv8M/non_secure/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/portable/ARMv8M/non_secure/portable/GCC/ARM_CM33_NTZ/: portasm.c
  group lvgl_port
    ../User/lvgl/: lv_port_disp.c
    ../User/lvgl/demo/: lv_demo.c
  group Third_Party/lvgl_v8.4
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/: lv_extra.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/layouts/flex/: lv_flex.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/layouts/grid/: lv_grid.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/libs/bmp/: lv_bmp.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/libs/freetype/: lv_freetype.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/libs/png/: lodepng.c lv_png.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/libs/rlottie/: lv_rlottie.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/others/gridnav/: lv_gridnav.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/others/ime/: lv_ime_pinyin.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/others/imgfont/: lv_imgfont.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/others/monkey/: lv_monkey.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/others/msg/: lv_msg.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/others/snapshot/: lv_snapshot.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/themes/basic/: lv_theme_basic.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/themes/default/: lv_theme_default.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/themes/mono/: lv_theme_mono.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/animimg/: lv_animimg.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/chart/: lv_chart.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/led/: lv_led.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/list/: lv_list.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/menu/: lv_menu.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/meter/: lv_meter.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/span/: lv_span.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/spinner/: lv_spinner.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/tabview/: lv_tabview.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/tileview/: lv_tileview.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/extra/widgets/win/: lv_win.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/src/draw/acm32_dma2d/: lv_gpu_acm32_dma2d.c
  group lvgl_v8.4/demo/
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/demos/keypad_encoder/: lv_demo_keypad_encoder.c
  group lvgl_v8.4/demo/benchmark
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/demos/benchmark/: lv_demo_benchmark.c
    ../../../../../../Middlewares/Third_Party/lvgl/lvgl-release-v8.4/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
