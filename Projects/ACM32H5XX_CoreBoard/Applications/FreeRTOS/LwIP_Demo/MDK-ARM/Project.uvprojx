# Keil uVision project Project.uvprojx, settings and files
target Project (6220000::V6.22::ARMCLANG)
  device: ACM32H528IIT7-G Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.2
  cpu: IRAM(0x20008000,0x00058000) IRAM2(0x20000000,0x00008000) IROM(0x08002000,0x001FE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __DSP_PRESENT,ACM32H5XX_176_EVB
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\User;..\MDK-ARM;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\include;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\portable\ARMv8M\non_secure\portable\GCC\ARM_CM33_NTZ;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\CMSIS_RTOS;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\lwip-2.2.1\src\include;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\lwip-2.2.1\src\include\lwip;..\User\LWIP\App;..\User\LWIP\Target;..\..\..\..\BSP\Eth;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\lwip-2.2.1\system;..\..\..\..\..\..\Middlewares\Third_Party\LwIP\lwip-2.2.1\system\arch;..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\FreeRTOS-Kernel-11.1.0\portable\ARMv8M\non_secure
  asm include: C:\Keil\ARM\INC\ARM;..\..\..\..\..\..\Middlewares\Third_Party\RTOS2\RTX\Include;..\..\..\..\..\..\Middlewares\Third_Party\RTOS2\RTX\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1fe000
  memory RVCT9: RAM 0x20008000 size 0x38000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Project.sct
  group Example/MDK-ARM
    ../../../../../../Drivers/Device/ARM/: startup_acm32h5xx.s
  group Drivers/CMSIS
    ../../../../../../Drivers/Device/: system_acm32h5xx.c system_accelerate.c
  group Example/User
    ../User/: main.c acm32h5xx_it.c acm32h5xx_hal_msp.c udpecho.c tcpecho.c app_ethernet.c ethernetif.c tcpclient.c udpclient.c
  group BSP
    ../../../../BSP/: acm32h5xx_coreboard.c
    ../../../../BSP/Eth/: bsp_eth.c bsp_lan8720.c
  group Drivers/HAL_Driver
    ../../../../../../Drivers/HAL_Driver/Src/: hal.c hal_rcc.c hal_cortex.c hal_exti.c hal_gpio.c hal_dma.c hal_uart.c hal_efuse.c hal_ospi.c hal_spi.c hal_eth.c
  group Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Third_Party/FreeRTOS/Port
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/portable/ARMv8M/non_secure/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/portable/ARMv8M/non_secure/portable/GCC/ARM_CM33_NTZ/: portasm.c mpu_wrappers_v2_asm.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/FreeRTOS-Kernel-11.1.0/portable/MemMang/: heap_4.c
  group Third_Party/LwIP/api
    ../../../../../../Middlewares/Third_Party/LwIP/lwip-2.2.1/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Third_Party/LwIP/core
    ../../../../../../Middlewares/Third_Party/LwIP/lwip-2.2.1/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../Middlewares/Third_Party/LwIP/lwip-2.2.1/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Third_Party/LwIP/netif
    ../../../../../../Middlewares/Third_Party/LwIP/lwip-2.2.1/src/netif/: ethernet.c
  group Third_Party/LwIP/arch
    ../../../../../../Middlewares/Third_Party/LwIP/lwip-2.2.1/system/OS/: sys_arch.c
