# Keil uVision project Project.uvprojx, settings and files
target DMA_IN_DTCM (6150000::V6.15::ARMCLANG)
  device: ACM32H5XX Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.2
  cpu: IRAM(0x20008000,0x00050000) IRAM2(0x20000000,0x00008000) IROM(0x08002000,0x001FE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c define: __DSP_PRESENT,VECT_TAB_SPI_FLASH
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\User;..\MDK-ARM
  asm include: C:\Keil\ARM\INC\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1fe000
  memory RVCT9: RAM 0x20008000 size 0x58000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Example/MDK-ARM
    ../../../../../../Drivers/Device/ARM/: startup_acm32h5xx.s
  group Example/User
    ../User/: main.c acm32h5xx_it.c acm32h5xx_hal_msp.c acm32h5xx_hal_conf.h app.c app_dma_data.c
  group BSP/ACM32H5XX_CoreBoard
    ../../../../BSP/: acm32h5xx_coreboard.c
  group Drivers/HAL_Driver
    ../../../../../../Drivers/HAL_Driver/Src/: hal.c hal_rcc.c hal_cortex.c hal_exti.c hal_gpio.c hal_uart.c hal_iwdt.c hal_pmu.c hal_wdt.c hal_dwt.c hal_dma.c hal_comp.c hal_efuse.c
  group Drivers/CMSIS
    ../../../../../../Drivers/Device/: system_acm32h5xx.c system_accelerate.c
target DMA_IN_SRAM (6150000::V6.15::ARMCLANG)
  device: ACM32H5XX Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.2
  cpu: as above
  output: Project +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c define: __DSP_PRESENT,VECT_TAB_SPI_FLASH
  c misc: -Wno-invalid-source-encoding
  c include: as above
  asm include: C:\Keil\ARM\INC\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1fe000
  memory RVCT9: RAM 0x20000000 size 0x58000
  memory RVCT10: RAM 0x20058000 size 0x8000
