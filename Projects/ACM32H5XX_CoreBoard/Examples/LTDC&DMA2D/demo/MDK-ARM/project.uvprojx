# Keil uVision project project.uvprojx, settings and files
target Run_In_SPIFLASH (6150000::V6.15::ARMCLANG)
  device: ACM32H5XX Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.2
  cpu: IRAM(0x20000000,0x00080000) IRAM2(0x20090000,0x00001000) IROM(0x08002000,0x001FE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: __DSP_PRESENT VECT_TAB_SPI_FLASH VECT_TAB_QSPI7_FLASH, M12L2561616A
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\User;..\MDK-ARM;..\..\..\..\..\..\Middlewares\Third_Party\ff\source;..\..\..\..\..\..\Middlewares\Third_Party\lvgl;..\..\..\..\..\..\Middlewares\Third_Party\lvgl\demos\benchmark;..\..\..\..\BSP\LTDC
  asm include: C:\Keil\ARM\INC\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1fe000
  memory RVCT9: RAM 0x20008000 size 0x30000
  memory RVCT10: RAM 0x20090000 size 0x1000
  scatter file: .\Project_user_spi_flash.sct
  group Example/MDK-ARM
    ../../../../../../Drivers/Device/ARM/: startup_acm32h5xx.s
  group Example/User
    ../User/: main.c app.c sdram.c acm32h5xx_it.c acm32h5xx_hal_msp.c acm32h5xx_hal_conf.h common.c xccela_opi.c drv_ospi.c
  group BSP/ACM32H5XX_CoreBoard
    ../../../../BSP/LTDC/: bsp_lcd.c
    ../../../../BSP/: acm32h5xx_coreboard.c
  group Drivers/HAL_Driver
    ../../../../../../Drivers/HAL_Driver/Src/: hal.c hal_cortex.c hal_dma.c hal_dwt.c hal_fmc.c hal_exti.c hal_gpio.c hal_rcc.c hal_uart.c hal_dma2d.c hal_ltdc.c hal_ospi.c hal_dcmi.c hal_i2c.c hal_efuse.c
  group Drivers/CMSIS
    ../../../../../../Drivers/Device/: system_accelerate.c system_acm32h5xx.c
