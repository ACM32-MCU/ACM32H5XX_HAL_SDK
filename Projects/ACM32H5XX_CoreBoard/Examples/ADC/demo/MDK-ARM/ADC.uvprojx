# Keil uVision project ADC.uvprojx, settings and files
target project (6150000::V6.15::ARMCLANG)
  device: ACM32H5XX Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.1
  cpu: IRAM(0x20008000,0x00050000) IRAM2(0x20000000,0x00008000) IROM(0x08002000,0x001FE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3
  c define: __DSP_PRESENT,VECT_TAB_SPI_FLASH
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\User;..\MDK-ARM
  asm include: C:\Keil\ARM\INC\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1fe000
  memory RVCT9: RAM 0x20008000 size 0x50000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Example/MDK-ARM
    ../../../../../../Drivers/Device/ARM/: startup_acm32h5xx.s
  group Example/User
    ../User/: main.c app.c acm32h5xx_it.c acm32h5xx_hal_msp.c acm32h5xx_hal_conf.h adc_regular.c adc_inject.c adc_interrupt.c adc_external.c adc_dma.c adc_analogwatchdog.c adc_dual.c
  group BSP/ACM32H5XX_CoreBoard
    ../../../../BSP/: acm32h5xx_coreboard.c
  group Drivers/HAL_Driver
    ../../../../../../Drivers/HAL_Driver/Src/: hal.c hal_rcc.c hal_cortex.c hal_exti.c hal_gpio.c hal_uart.c hal_adc.c hal_dwt.c hal_dma.c hal_efuse.c
  group Drivers/CMSIS
    ../../../../../../Drivers/Device/: system_acm32h5xx.c system_accelerate.c
  group Doc
    ../: readme.txt
