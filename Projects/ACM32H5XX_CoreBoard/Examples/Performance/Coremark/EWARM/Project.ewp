# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pe550,Pe177,Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS; ..\..\..\..\..\..\Drivers\Device; ..\..\..\..\..\..\Drivers\HAL_Driver\Inc; ..\..\..\..\BSP; ..\User; ..\User\coremark_Code
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: acm32h5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group BSP/CoreBoard
    ../../../../BSP/: acm32h5xx_coreboard.c
  group CoreDriver/CMSIS
    ../../../../../../Drivers/CMSIS/: core_cm33.h
  group CoreDriver/Device
    ../../../../../../Drivers/Device/: acm32h5xx.h system_accelerate.c system_accelerate.h system_acm32h5xx.c system_acm32h5xx.h
  group CoreDriver/HAL
    ../../../../../../Drivers/HAL_Driver/Src/: hal.c hal_cortex.c hal_dma.c hal_dwt.c hal_efuse.c hal_exti.c hal_gpio.c hal_rcc.c hal_uart.c
  group Startup
    ../../../../../../Drivers/Device/IAR/: startup_acm32h5xx.s
  group User
    ../User/: acm32h5xx_hal_conf.h acm32h5xx_hal_msp.c acm32h5xx_it.c acm32h5xx_it.h main.c main.h nop.c
  group User/User/Coremark
    ../User/coremark_Code/: core_list_join.c core_main.c core_matrix.c core_portme.c core_portme.h core_state.c core_util.c coremark.h
