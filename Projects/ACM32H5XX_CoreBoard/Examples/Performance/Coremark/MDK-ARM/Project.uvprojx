# Keil uVision project Project.uvprojx, settings and files
target project (6150000::V6.15::ARMCLANG)
  device: ACM32H5XX Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.1
  cpu: IRAM(0x20008000,0x00050000) IRAM2(0x20000000,0x00008000) IROM(0x08002000,0x001FE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DSP_PRESENT,KEIL_MDK_ARM
  c misc: -Wno-invalid-source-encoding -Wall -Werror
  c include: ..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\User
  asm include: C:\Keil\ARM\INC\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1fe000
  memory RVCT9: RAM 0x20038000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Example/MDK-ARM
    ../User/: startup_acm32h5xx.s
  group Drivers/Device
    ../../../../../../Drivers/Device/: system_accelerate.c system_acm32h5xx.c
  group Drivers/HAL_Driver
    ../../../../../../Drivers/HAL_Driver/Src/: hal.c hal_cortex.c hal_rcc.c hal_dwt.c hal_efuse.c hal_gpio.c hal_uart.c hal_dma.c hal_exti.c
  group BSP/ACM32H5XX_CoreBoard
    ../../../../BSP/: acm32h5xx_coreboard.c
  group Example/User
    ../User/: acm32h5xx_hal_conf.h acm32h5xx_it.c acm32h5xx_hal_msp.c main.c nop.c
  group Example/User/coremark
    ../User/coremark_Code/: core_list_join.c core_main.c core_matrix.c core_portme.c core_portme.h core_state.c core_util.c coremark.h
