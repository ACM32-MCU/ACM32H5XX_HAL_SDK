# Keil uVision project Project.uvprojx, settings and files
target RUN_IN_ROM (6150000::V6.15::ARMCLANG)
  device: ACM32H5XX_ROM Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.1
  cpu: IRAM(0x20008000,0x00050000) IRAM2(0x20000000,0x00008000) IROM(0x0,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DSP_PRESENT  VECT_TAB_ROM
  c misc: -Wno-invalid-source-encoding -mcpu=cortex-m33+cdecp0
  c include: ..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\User;..\MDK-ARM;..\User
  asm include: C:\Keil\ARM\INC\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20008000 size 0x50000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Example/MDK-ARM
    ../../../../../../Drivers/Device/ARM/: startup_acm32h5xx.s
  group Drivers/CMSIS
    ../../../../../../Drivers/Device/: system_acm32h5xx.c system_accelerate.c
  group Drivers/HAL_Driver
    ../../../../../../Drivers/HAL_Driver/Src/: hal_cortex.c hal.c hal_rcc.c hal_gpio.c hal_exti.c hal_uart.c hal_dma.c hal_nand.c hal_cde.c hal_dwt.c hal_efuse.c hal_sm3_20241118.lib
  group BSP/FPC2042_CoreBoard
    ../../../../BSP/: acm32h5xx_coreboard.c
  group Example/User
    ../User/: acm32h5xx_hal_conf.h acm32h5xx_it.c acm32h5xx_hal_msp.c main.c app.c
target RUN_IN_XIP (6160000::V6.16::ARMCLANG)
  device: ACM32H5XX Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.1
  cpu: IRAM(0x20008000,0x00050000) IRAM2(0x20000000,0x00008000) IROM(0x08002000,0x001FE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf.exe --bin -c --cpu=cortex-m33 --coproc0=CDE --output ./Out_Files/Project.bin ./Objects/Project.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DSP_PRESENT  VECT_TAB_SPI_FLASH
  c misc: -Wno-invalid-source-encoding -mcpu=cortex-m33+cdecp0
  c include: ..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\User;..\MDK-ARM
  asm include: C:\Keil\ARM\INC\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1fe000
  memory RVCT9: RAM 0x20008000 size 0x50000
  memory RVCT10: RAM 0x20000000 size 0x8000
