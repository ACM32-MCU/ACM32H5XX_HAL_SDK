# Keil uVision project Project.uvprojx, settings and files
target Project_UTMI_PHY (6150000::V6.15::ARMCLANG)
  device: ACM32H5XX Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.1
  cpu: IRAM(0x20008000,0x00050000) IRAM2(0x20000000,0x00008000) IROM(0x08002000,0x00FFE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: cmd.exe /C copy .\Objects\Project.axf .\Out_Files
  AfterMake: fromelf.exe --i32 --output ./Out_Files/Project.hex ./Out_Files/Project.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __DSP_PRESENT VECT_TAB_SPI_FLASH
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\User;..\MDK-ARM;..\Lib\usbh;..\Lib\usbh\Core\Inc;..\Lib\usbh\Class\bulk\Inc;..\Lib\usbh\Class\hid\Inc
  asm include: C:\Keil\ARM\INC\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xffe000
  memory RVCT9: RAM 0x20008000 size 0x50000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Example/MDK-ARM
    ../../../../../../Drivers/Device/ARM/: startup_acm32h5xx.s
  group Drivers/CMSIS
    ../../../../../../Drivers/Device/: system_acm32h5xx.c system_accelerate.c
  group BSP
    ../../../../BSP/: acm32h5xx_coreboard.c
  group Drivers/HAL_Driver
    ../../../../../../Drivers/HAL_Driver/Src/: hal.c hal_rcc.c hal_cortex.c hal_exti.c hal_gpio.c hal_uart.c HAL_HCD.c LL_USB.c hal_dma.c hal_efuse.c
  group Library/usbh/core
    ../Lib/usbh/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Library/usbh/class/bulk
    ../User/: usbh_conf.c
    ../Lib/usbh/Class/bulk/Src/: usbh_bulk.c usbh_vendor_class.c
  group Example/User
    ../User/: main.c acm32h5xx_it.c acm32h5xx_hal_msp.c
  group Doc
    ../: readme.txt
target Project_Serial_PHY (6150000::V6.15::ARMCLANG)
  device: ACM32H5XX Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.1
  cpu: as above
  output: Project +hex
  AfterMake: cmd.exe /C copy .\Objects\Project.axf .\Out_Files
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __DSP_PRESENT VECT_TAB_SPI_FLASH  USE_USB_SERIAL_PHY
  c misc: -Wno-invalid-source-encoding
  c include: as above
  asm include: C:\Keil\ARM\INC\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0xffe000
  memory RVCT9: RAM 0x20008000 size 0x50000
  memory RVCT10: RAM 0x20000000 size 0x8000
