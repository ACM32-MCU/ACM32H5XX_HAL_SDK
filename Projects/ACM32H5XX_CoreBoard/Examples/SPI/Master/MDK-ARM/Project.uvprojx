# Keil uVision project Project.uvprojx, settings and files
target Project (6220000::V6.22::ARMCLANG)
  device: ACM32H5XX Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.1
  cpu: IRAM(0x20000000,0x00080000) IRAM2(0x20090000,0x00001000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DSP_PRESENT VECT_TAB_SPI_FLASH
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\..\..\BSP\Common;..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\User;..\MDK-ARM;..\..\..\..\BSP\NorFlash;..\..\..\..\BSP\EEPROM;..\..\..\..\BSP\PSRAM
  asm include: C:\Keil\ARM\INC\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x20000
  memory RVCT9: RAM 0x20008000 size 0x50000
  memory RVCT10: RAM 0x20090000 size 0x1000
  group Example/MDK-ARM
    ../../../../../../Drivers/Device/ARM/: startup_acm32h5xx.s
  group Drivers/CMSIS
    ../../../../../../Drivers/Device/: System_Accelerate.c system_acm32h5xx.c
  group Drivers/HAL_Driver
    ../../../../../../Drivers/HAL_Driver/Src/: hal.c hal_rcc.c hal_gpio.c hal_exti.c hal_uart.c hal_cortex.c hal_spi.c hal_efuse.c hal_dma.c
  group BSP/ACM32H5XX_CoreBoard
    ../../../../BSP/: acm32h5xx_coreboard.c
  group Example/User
    ../User/: acm32h5xx_hal_conf.h acm32h5xx_it.c acm32h5xx_hal_msp.c app.c main.c
    ../../../../BSP/NorFlash/: ic_w25qxx.c
target rom_debug (6160000::V6.16::ARMCLANG)
  device: ACM32H5XX Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.1
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __DSP_PRESENT VECT_TAB_SPI_FLASH
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\..\..\..\..\Drivers\CMSIS;..\..\..\..\..\..\Drivers\Device;..\..\..\..\..\..\Drivers\HAL_Driver\Inc;..\..\..\..\BSP;..\User;..\MDK-ARM;..\..\..\..\BSP\Common;..\..\..\..\BSP\NorFlash;..\..\..\..\BSP\EEPROM;..\..\..\..\BSP\PSRAM
  asm include: C:\Keil\ARM\INC\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20008000 size 0x50000
  memory RVCT10: RAM 0x20090000 size 0x1000
