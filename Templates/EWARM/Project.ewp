# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pe550,Pe177,Pa082
  ICCARM.CCIncludePath2: ..\..\Drivers\CMSIS; ..\..\Drivers\Device\ARM; ..\..\Drivers\HAL_Driver\Inc; ..\..\Drivers\Device; ..\..\Projects\ACM32H5XX_CoreBoard\BSP; ..\User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: acm32h5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP/CoreBoard
    ../../Projects/ACM32H5XX_CoreBoard/BSP/: acm32h5xx_coreboard.c
  group CoreDriver/CMSIS
    ../../Drivers/CMSIS/: core_cm33.h
  group CoreDriver/Device
    ../../Drivers/Device/: acm32h5xx.h system_accelerate.c system_acm32h5xx.c
  group CoreDriver/HAL
    ../../Drivers/HAL_Driver/Src/: hal.c hal_adc.c hal_aes_spi1.c hal_cde.c hal_comp.c hal_cortex.c hal_crc.c hal_dac.c hal_dcmi.c hal_dma.c hal_dma2d.c hal_dwt.c hal_efuse.c hal_eth.c hal_exti.c hal_fdcan.c hal_fmc.c hal_gpio.c HAL_HCD.c hal_i2c.c hal_i2s.c hal_iwdt.c hal_lptim.c hal_lpuart.c hal_ltdc.c hal_mdac.c hal_nand.c hal_norflash.c hal_ospi.c HAL_PCD.c HAL_PCD_EX.c hal_pmu.c hal_rcc.c hal_rtc.c hal_sdmmc.c hal_spi.c hal_timer.c hal_timer_ex.c hal_tkey .c hal_uart.c hal_uart_7816m.c hal_uart_ex.c hal_usart.c hal_wdt.c LL_USB.c
  group SourceCode/main
    ../User/: acm32h5xx_hal_conf.h acm32h5xx_hal_msp.c acm32h5xx_it.c app.c main.c
  group Startup
    ../../Drivers/Device/IAR/: startup_acm32h5xx.s
