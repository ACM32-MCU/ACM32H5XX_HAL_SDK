# Keil uVision project Project.uvprojx, settings and files
target Project (6140000::V6.14::ARMCLANG)
  device: ACM32H5XX Aisinochip
  pack: Aisinochip.ACM32H5XX.1.0.2
  cpu: IRAM(0x20008000,0x00050000) IRAM2(0x20000000,0x00008000) IROM(0x08002000,0x00FFE000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CDECP(0xFF) CLOCK(12000000) ELITTLE
  output: Project +hex
  group Example/MDK-GCC
    ../../Drivers/Device/GCC/: syscalls.c startup_acm32h5xx.S
  group Drivers/HAL_Driver
    ../../Drivers/HAL_Driver/Src/: hal_cortex.c hal.c hal_rcc.c hal_gpio.c hal_exti.c hal_dma.c hal_uart.c hal_efuse.c
  group BSP/ACM32H5XX_CoreBoard
    ../../Projects/ACM32H5XX_CoreBoard/BSP/: acm32h5xx_coreboard.c
  group Example/User
    ../User/: acm32h5xx_hal_conf.h acm32h5xx_it.c acm32h5xx_hal_msp.c app.c main.c
  group Drivers/CMSIS
    ../../Drivers/Device/: system_accelerate.c system_acm32h5xx.c
